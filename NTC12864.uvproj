# Keil uVision project NTC12864.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: NTC12864 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51
    ./Source/: main.c SH1106_12864.c pca.c NTC.c timer.c stceeprom.c pid.c key.c Uart.c
